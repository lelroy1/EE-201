# Repository lelroy1/EE-201

File README.md:

# Personal Webpage for Lucas Elroy

## KiCad design lab4/LED Circuit/LED.kicad_pcb

Board: 2 copper layers, 73.7 x 43.2 mm, 6 parts (0 on the bottom side), 5 nets.

Parts:
C1: 4.7uF; C_Radial_D5.0mm_H5.0mm_P2.00mm
D1: LED; LED_D5.0mm
R1: 20k; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal
R2: 2.2k; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal
SW1: SW_SPDT; SW_E-Switch_EG1224_SPDT_Angled
V1: 9V; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical

Connections:
unnamed: C1.1, R1.2, SW1.3 (C)
unnamed: C1.2, D1.1 (K), V1.2 (-)
unnamed: D1.2 (A), R1.1
unnamed: R2.1, V1.1 (+)
unnamed: R2.2, SW1.2 (B)

## KiCad design lab4/555 Circuit/ee210.kicad_pcb

Parts:
C1: 10 uF
C2: .01 uF
D1, D2: LED
R1, R3, R4: 1k
R2: 10k
U1: NE555D; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+9V: D1.2 (A), R1.1, U1.4 (R), U1.8 (VCC); also elsewhere on the board
/pin_2: C1.1, R2.2, U1.2 (TR), U1.6 (THR)
/pin_3: R3.1, R4.1, U1.3 (Q)
/pin_7: R1.2, R2.1, U1.7 (DIS)
GND: C1.2, C2.2, D2.1 (K), U1.1 (GND); also elsewhere on the board
unnamed: C2.1, U1.5 (CV)
unnamed: D1.1 (K), R3.2
unnamed: D2.2 (A), R4.2

Board: 2 copper layers, 40.6 x 48.3 mm, 10 parts (0 on the bottom side), 8 nets.

Other parts of the board:
J1: Conn_01x02_Male; TerminalBlock_bornier-2_P5.08mm

Their connections:
+9V: J1.1; also elsewhere on the board
GND: J1.2; also elsewhere on the board

## Commit log

2023-01-13 test1
2023-01-13 test
2023-01-21 itit commit
2023-01-21 add repo
2023-01-28 lab4
2023-02-04 solder
2023-02-11 “tes”
2023-02-17 lab7
